# Keil uVision project project.uvprojx, settings and files
target RT-Thread (ARM-ADS)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread-k64f
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MKL26Z256VLH4, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;../../components/net/at/include;../../components/net/at/at_socket;packages/at_device-latest/inc;packages/at_device-latest/class/esp8266;../../components/libc/compilers/common;../../components/libc/compilers/common/extension;../../components/libc/compilers/common/extension/fcntl/octal;../../libcpu/arm/common;../../libcpu/arm/cortex-m0;../../components/drivers/include;../../components/drivers/include;../../components/drivers/include;device;device/MKL26Z4;board;../../components/finsh;.;../../include;../../components/libc/posix/io/poll;../../components/libc/posix/io/stdio;../../components/libc/posix/ipc;../../components/net/netdev/include;../../components/net/sal/include;../../components/net/sal/include/socket;../../components/net/sal/impl;../../components/net/sal/include/socket/sys_socket
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group Applications
    applications/: startup.c application.c
  group AT
    ../../components/net/at/at_socket/: at_socket.c
    ../../components/net/at/src/: at_utils.c at_client.c at_cli.c
  group at_device
    packages/at_device-latest/class/esp8266/: at_socket_esp8266.c at_device_esp8266.c
    packages/at_device-latest/samples/: at_sample_esp8266.c
    packages/at_device-latest/src/: at_device.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c clock_config.c drv_led.c drv_uart.c peripherals.c pin_mux.c
    device/MKL26Z4/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_cop.c fsl_dac.c fsl_dma.c fsl_dmamux.c fsl_ftfx_cache.c fsl_ftfx_controller.c fsl_ftfx_flash.c fsl_ftfx_flexnvm.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_llwu.c fsl_lpsci.c fsl_lpsci_dma.c fsl_lptmr.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rtc.c fsl_sai.c fsl_sai_dma.c fsl_sim.c fsl_smc.c fsl_spi.c fsl_spi_dma.c fsl_tpm.c fsl_tsi_v4.c fsl_uart.c fsl_uart_dma.c
    device/TOOLCHAIN_ARM_STD/: startup_MKL26Z4.s
    device/: system_MKL26Z4.c
  group Finsh
    ../../components/finsh/: cmd.c msh.c shell.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group SAL
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../components/net/sal/impl/: af_inet_at.c
    ../../components/net/sal/socket/: net_netdb.c
    ../../components/net/sal/src/: sal_socket.c
software components: CMSIS:CORE 5.0.1
