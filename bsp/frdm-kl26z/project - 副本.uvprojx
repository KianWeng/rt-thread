# Keil uVision project project - 副本.uvprojx, settings and files
target RT-Thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL26Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rt-thread-k64f
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __RTTHREAD__,DEBUG, CPU_MKL26Z256VLH4,  FRDM_KL26Z, FREEDOM,RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;../../components/net/at/include;../../components/net/at/at_socket;../../components/libc/compilers/common;../../components/libc/compilers/common/extension;../../components/libc/compilers/common/extension/fcntl/octal;../../libcpu/arm/common;../../libcpu/arm/cortex-m0;../../components/drivers/include;../../components/drivers/include;../../components/drivers/include;device;device/MKL26Z4;board;../../components/finsh;.;../../include;../../components/libc/posix/io/poll;../../components/libc/posix/io/stdio;../../components/libc/posix/ipc;../../components/net/netdev/include;../../components/net/sal/include;../../components/net/sal/include/socket;../../components/net/sal/impl;../../components/net/sal/include/socket/sys_socket
  asm define: __EVAL,DEBUG
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: .\KL26Z.scf
  group Applications
    applications/: startup.c application.c
    ./applications/: esp8266_at.c
  group AT
    ../../components/net/at/src/: at_utils.c at_client.c at_cli.c
    ../../components/net/at/at_socket/: at_socket.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    device/MKL26Z4/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_cop.c fsl_dac.c fsl_dma.c fsl_dmamux.c fsl_ftfx_cache.c fsl_ftfx_controller.c fsl_ftfx_flash.c fsl_ftfx_flexnvm.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_llwu.c fsl_lpsci.c fsl_lpsci_dma.c fsl_lptmr.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rtc.c fsl_sai.c fsl_sai_dma.c fsl_sim.c fsl_smc.c fsl_spi.c fsl_spi_dma.c fsl_tpm.c fsl_tsi_v4.c fsl_uart.c fsl_uart_dma.c
    device/TOOLCHAIN_ARM_STD/: startup_MKL26Z4.s
    device/: system_MKL26Z4.c
  group Finsh
    ../../components/finsh/: cmd.c shell.c msh.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group board
    ./board/: clock_config.c peripherals.c pin_mux.c board.c
  group hal
    ./board/: drv_uart.c
  group PeripheralDrivers
    ./board/: drv_led.c drv_oled.c drv_key.c at_device.c at_device_esp8266.c at_socket_esp8266.c
  group SAL
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../components/net/sal/impl/: af_inet_at.c
    ../../components/net/sal/socket/: net_netdb.c
    ../../components/net/sal/src/: sal_socket.c
