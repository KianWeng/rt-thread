# Keil uVision project project.uvproj, settings and files
target RT-Thread (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: rt-thread-k64f
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CPU_MK64FN1M0VLL12, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\extension;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;board;device;device\MK64F12;..\..\components\finsh;.;..\..\include;..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\components\net\lwip\lwip-2.0.3\src\include\posix;..\..\components\net\lwip\port;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\io\stdio;..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group Applications
    applications/: startup.c application.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/ipc/: workqueue.c dataqueue.c waitqueue.c pipe.c ringbuffer.c completion.c ringblk_buf.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    board/: drv_uart.c clock_config.c fsl_phy.c led.c drv_emac.c board.c
    device/MK64F12/: fsl_enet.c fsl_smc.c fsl_clock.c fsl_lptmr.c fsl_common.c fsl_wdog.c fsl_crc.c fsl_gpio.c fsl_rnga.c fsl_dspi_edma.c fsl_flexcan.c fsl_sdhc.c fsl_cmt.c fsl_rtc.c fsl_dmamux.c fsl_ftm.c fsl_adc16.c fsl_pmc.c fsl_sai_edma.c fsl_flash.c fsl_flexbus.c fsl_sim.c fsl_i2c_edma.c fsl_cmp.c fsl_uart_edma.c fsl_sysmpu.c fsl_i2c.c fsl_edma.c fsl_llwu.c fsl_uart.c fsl_dspi.c fsl_sai.c fsl_rcm.c fsl_pdb.c fsl_vref.c fsl_pit.c fsl_dac.c fsl_ewm.c
    device/: system_MK64F12.c
    device/TOOLCHAIN_ARM_STD/: startup_MK64F12.s
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: clock.c mem.c thread.c mempool.c timer.c components.c object.c irq.c scheduler.c device.c kservice.c ipc.c idle.c
  group lwIP
    ../../components/net/lwip/lwip-2.0.3/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    ../../components/net/lwip/lwip-2.0.3/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    ../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
